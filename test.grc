options:
  parameters:
    generate_options: qt_gui
    id: lab1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW_Costas
  id: variable_qtgui_range
  parameters:
    label: Costas BandWidth
    start: '0.00001'
    step: '0.0000002'
    stop: '0.05'
    value: '0.025'
  states: {}
- name: BW_Gardner
  id: variable_qtgui_range
  parameters:
    label: Gardner BandWidth
    start: '0.00001'
    step: '0.0000002'
    stop: '0.05'
    value: '0.05'
  states: {}
- name: RX_GAIN
  id: variable_qtgui_range
  parameters:
    label: Gain
    rangeType: int
    start: '5'
    step: '1'
    stop: '75'
    value: '25'
    widget: counter
  states: {}
- name: bpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j,  1+1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qpsk_1
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 700.7*1e6
    step: 0.0125*1e3
    stop: 2907.1*1e6
    value: 734.750*1e6
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: 2**10
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '10'
  states: {state: disabled}
- name: digital_costas_loop_cc_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: BW_Costas
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: BW_Gardner
    max_dev: '1.0'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: int(tune)
    samplerate: samp_rate
    type: fc32
    uri: usb:3.7.5
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: 32768*4
    filter_source: '''Auto'''
    frequency: int(tune)
    gain1: '''manual'''
    manual_gain1: RX_GAIN
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: 2**13
    type: complex
    update_time: '0.000000010'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"Without Costas"'
    size: 2**13
    type: complex
    update_time: '0.00010'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: bw
    type: complex
    update_time: '0.000010'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*10
    samp_rate: samp_rate
    sym_rate: samp_rate/10
    type: fir_filter_ccf
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_costas_loop_cc_0_1, '0', qtgui_const_sink_x_0_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
